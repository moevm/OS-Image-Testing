IMAGE_INSTALL:append = " chaosblade"
