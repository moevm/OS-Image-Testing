IMAGE_INSTALL:append = " packagegroup-ltp"
