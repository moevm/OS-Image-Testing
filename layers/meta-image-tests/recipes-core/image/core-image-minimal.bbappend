IMAGE_INSTALL:append = " packagegroup"
