SUMMARY = "Packagegroup LTP"
LICENSE = "MIT"
inherit packagegroup

RDEPENDS:${PN} = "ltp fwts"
