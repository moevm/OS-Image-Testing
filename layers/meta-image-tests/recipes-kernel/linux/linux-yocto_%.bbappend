FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://dmsetup.cfg"
